{attribute 'pack_mode' := '8'} 
TYPE stAcquisitionBlock :
STRUCT
	DataBlock : ARRAY [0..nAcquisitionBlock] OF stAcquisitionData;		(*  Put one Acq Block into fifo buffer *)
END_STRUCT
END_TYPE
