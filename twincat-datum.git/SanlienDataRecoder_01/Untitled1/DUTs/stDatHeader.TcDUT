{attribute 'pack_mode' := '8'} 
TYPE stDatHeader :	(* Beware memory alignment *)
STRUCT
	PlaseHolder: ARRAY[0..1023] OF BYTE;
END_STRUCT
END_TYPE
